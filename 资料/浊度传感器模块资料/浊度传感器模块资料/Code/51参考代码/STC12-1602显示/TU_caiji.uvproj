# Keil uVision project TU_caiji.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: PH_caiji +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User
  group Source Group 1
    ./: STARTUP.A51
    ./User/: main.c DS18B20.c
